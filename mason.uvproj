# Keil uVision project mason.uvproj, settings and files
target Mason (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: mason_app +hex
  BeforeMake: before-build.bat
  AfterMake: fromelf --bin --output mason_app.bin ./Objects/mason_app.axf
  AfterMake: after-build.bat mason_app FW_APP_
  c flags: wLevel=2
  c misc: -Ospace --c99
  c include: .\source\CMSIS\Include;.\source\system;.\source\driver;.\source\mason;.\source\COMMON;.\source\crypto;.\source;.\source\driver\ed25519-donna;.\source\driver\sr25519;.\source\substrate
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x24000
  memory RVCT9: RAM 0x68000000 size 0x4000
  group system
    ./source/system/: startup.s system_se.c
  group driver
    ./source/driver/: uart.c gpio.c timer.c wdt.c eflash.c ecdsa_v2.lib hrng_v2.lib sha2.c pki_v1.lib rsa_v1.lib
    ./source/driver/ed25519-donna/: ed25519.c
    ./source/driver/sr25519/: merlin.c ristretto-donna.c sr25519.c
  group common
    ./source/COMMON/: common.c circular_buffer.c TLV.c queue.c stack.c util.c
  group crypto
    ./source/crypto/: crypto_api.c bip39.c bip44.c secp256.c base58.c RipeMD160.c hmac.c pbkdf2.c slip39_encrypt.c
  group app
    ./source/: main.c version_def.c
  group mason
    ./source/mason/: mason_comm.c mason_commands.c mason_storage.c mason_iap.c mason_wallet.c mason_hdw.c mason_key.c mason_setting.c
  group substrate
    ./source/substrate/: substrate_sign.c
